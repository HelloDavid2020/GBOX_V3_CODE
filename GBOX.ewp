# IAR project GBOX.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsdn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: WDG; DEBUG
  ICC430.newCCIncludePaths: $TOOLKIT_DIR$\inc; ; ADC; CLOCK; CONFIG; EEPROM; GPS; GSM; GPIO; PACKDATA; RTC; SYSTEM; TIME; UART
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: device.c isr.c main.c main.h
  group ADC
    ADC/: adc.c adc.h
  group CLOCK
    CLOCK/: clock.c clock.h
  group CONFIG
    CONFIG/: config.c config.h
  group EEPROM
    EEPROM/: at24c512.c at24c512.h
  group GPIO
    GPIO/: key.c led.c
  group GPS
    GPS/: ublox.c ublox.h
  group GSM
    GSM/: mg323b.c mg323b.h
  group PACKDATA
    PACKDATA/: packdata.c packdata.h
  group RTC
    RTC/: sd2068.c sd2068.h
  group SYSTEM
    SYSTEM/: system.c system.h
  group TIME
    TIME/: time.c time.h
  group UART
    UART/: uart.c uart.h
